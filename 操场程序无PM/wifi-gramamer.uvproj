# Keil uVision project wifi-gramamer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: wifi-gramamer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\操场程序无PM
  group Source Group 1
    ./: STARTUP.A51 DHT_T_RH.C wifi_gramamer.c
