# Keil uVision project wifi-main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: wifi-main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 wifi-main.c 12864.c
