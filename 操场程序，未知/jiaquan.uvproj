# Keil uVision project jiaquan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: jiaquan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\PM2.5
  group Source Group 1
    ./: STARTUP.A51 main.c DHT_T_RH.C wifi_gramamer.c head_file.h
